# Keil uVision project PDOD-01.uvproj, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: PDOD-01 +hex
  AfterMake: fromelf --bin --output="$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=16000000
  c include: .\STM32F4xx_StdPeriph_Driver\inc;.\bsp;.\driver;..\PDOD;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\PDOD-01.sct
  group bsp
    ./bsp/: RTX_Conf_CM.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s SVC_Table.s
  group main
    ./: main.c task_modbus.c task_time.c std.c
  group driver
    ./driver/: uart1.c ADC.c update.c modbus.c crc16.c config.c queue.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma.c
